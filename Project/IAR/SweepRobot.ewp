# IAR project SweepRobot.ewp, settings and files
configuration DB-ROBOT-S1 (ARM)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; DEBUG_LOG; USE_IAR_EWARM; __USE_SWRB_TEST; REVISION_1_2; STM32F10X_HD; CLOCK_HSE; USE_STDPERIPH_DRIVER; KEY_PROC_WITH_REMOTE; KEY_PROC_WITH_LED
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F10x_Ext\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\User\Framework\Common\inc; ..\..\User; ..\..\User\BSP\inc; ..\..\User\Framework; ..\..\User\APP; ..\..\User\Framework\UI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DB-ROBOT-S1.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DB-ROBOT-S2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration DB-ROBOT-S3 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SWRB_TEST; USE_IAR_EWARM; DEBUG_BM; DEBUG_LOG; REVISION_1_2; STM32F10X_HD; CLOCK_HSE; USE_STDPERIPH_DRIVER; KEY_PROC_WITH_REMOTE; KEY_PROC_WITH_LED
  ICCARM.CCIncludePath2: ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32F10x_Ext\inc; ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\CMSIS\Include; ..\..\User; ..\..\User\APP; ..\..\User\BSP; ..\..\User\BSP\inc; ..\..\User\Framework\Common\inc; ..\..\User\Framework\UI; ..\..\User\Framework
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group LIB/STM32F10x_Ext
    ../../Libraries/STM32F10x_Ext/src/: stm32f10x_it.c stm32f10x_UserMEM.c Usart.c
  group LIB/STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: boardcfg.h main.c stm32f10x_conf.h
  group USER/APP
    ../../User/APP/: SweepRobot.c SweepRobotTest.c
  group USER/BSP
    ../../User/BSP/src/: BatteryManage.c Buzzer.c IrDA.c Measurement.c MotorCtrl.c PWM.c RTC.c WWDG.c
  group USER/Framework
    ../../User/Framework/: MotionCtrl.c MsgQueue.c
  group USER/Framework/Common
    ../../User/Framework/Common/src/: delay.c nvram.c PwrManagement.c
  group USER/Framework/UI
    ../../User/Framework/UI/: CtrlPanel.c key.c
